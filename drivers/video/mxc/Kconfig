## drivers/video/mxc/Kconfig
```kconfig
config FB_MXC_EINK_PANEL
        depends on DMA_ENGINE
        select FB_DEFERRED_IO
        tristate "E-Ink Panel Framebuffer"
```
